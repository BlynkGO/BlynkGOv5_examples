#include <BlynkGOv5.h>

GRect FrameScroll;            // วิตเจ็ตนอก ไว้ทำเป็นช่อง view สำหรับแสดง ตัว scroll
  GRect rect(FrameScroll);    // วิตเจ็ตภายใน ที่มีขนาดใหญ่กว่า ช่อง view

void setup(){
  Serial.begin(9600); Serial.println();
  BlynkGO.begin();

  FrameScroll.size(300,300);                // ขนาด FrameScroll สำหรับเป็นช่อง view ให้เล็กกว่า สิ่งที่อยู่ภายในที่จะถูก scroll
  FrameScroll.scrollable(true);             // กำหนดให้ สามารถ scroll ได้
  FrameScroll.scrollbar(SCROLLBAR_OFF);     // ไม่ต้องแสดงแถบ scrollbar
  FrameScroll.scroll_elastic(false);        // จุดเริ่มต้น และปลาย เวลา scroll ไปถึง ไม่ต้องมี การแสดงกราฟิกเด้ง
  FrameScroll.bg_opa(0);                    // พื้นหลัง ไม่แสดง ใช้แค่ความสามารถด้าน scroll
    rect.size(300, 1000);                   // วิตเจ็ตที่จะเป็น content ภายใน มีขนาดใหญ่กว่า FrameScroll
    rect.color(TFT_BLUE, TFT_RED);
    rect.align(ALIGN_TOP_LEFT);
    rect.onDrawMain(GWIDGET_CB{             // วาดสิ่งต่างๆ ภายใน rect ด้วย กราฟิกระดับล่างเอง แบบ ไม่พึ่งวิตเจ็ต 
      for(int i=0; i<20; i++){
        // วาดเส้นระดับล่าง จากจุด 2 จุดที่กำหนด ความหนา 1 px แบบช่องประ กว้าง 4px ช่องเว้นประ 4px สีขาว โปร่งใส 30% (ประหยัดเม็มไม่ต้องใช้วิตเจ็ต GLine)
        if(i>0) rect.softdrawLine(Point(0, i*50), Point(rect.width()-1,i*50), 1, 4, 4, TFT_WHITE, OPA_30);
        // วาดข้อความระดับล่าง ด้วยฟอนต์ สี และจัดตำแหน่ง align ที่ต้องการ (ทำให้ประหยัดเม็มในการสร้างเป็นวิตเจ็ต GLabel)
        rect.softdrawLabel(StringX::printf("%d",i*50), prasanmit_18, TFT_WHITE, ALIGN_TOP, 0, i*50);
      }
    });

  //----------- Scroll มีการ Snape ที่ ทุกๆ 100 px --------------------
  // 📌 เพิ่ม event ให้ Scroll มีการ Snap ทุกๆ 100px
  //---------------------------------------------------------------
  FrameScroll.event_cb([](GWIDGET, event_t event)  {
    if(event == EVENT_SCROLL_END){
      int32_t y = FrameScroll.scroll_y();  // ค่าตำแหน่ง scroll แกน y ปัจจุบัน
      int32_t step = 100;
      // หา step ที่ใกล้ที่สุด
      int32_t y_snapped = ((y + step/2) / step) * step;
      // สั่ง scroll แบบ smooth ไปยังตำแหน่ง snap
      FrameScroll.scroll_to_y(y_snapped, 200); // 200ms animation
    }
  });

  //----------- Best Snape ตาม vector snapes ---------------------
  // 📌 เพิ่ม event ให้ Best Snap ตาม vector snaps
  //--------------------------------------------------------------
  // FrameScroll.event_cb([](GWIDGET, event_t event)  {
  //   if(event == EVENT_SCROLL_END){
  //     // กำหนดตำแหน่ง snap ตามต้องการ
  //     std::vector<int32_t> snaps = {0, 75, 150, 200, 400, 600, 700};

  //     int32_t y = FrameScroll.scroll_y();   // ตำแหน่งปัจจุบัน
  //     int32_t best_snap = snaps[0];
  //     int32_t best_diff = abs(y - snaps[0]);

  //     // หา snap point ที่ใกล้ที่สุด
  //     for(size_t i=1; i<snaps.size(); i++){
  //       int32_t diff = abs(y - snaps[i]);
  //       if(diff < best_diff){
  //         best_diff = diff;
  //         best_snap = snaps[i];
  //       }
  //     }

  //     // scroll ไปยัง snap ที่ใกล้ที่สุด
  //     FrameScroll.scroll_to_y(best_snap, 200);
  //   }
  // });
}

void loop(){
  BlynkGO.update();
}
